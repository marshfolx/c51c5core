# Keil uVision project c51c5core.uvproj, settings and files
target c51c5core (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: c51c5core +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Program Files\Keilv5\C51\INC
  link misc: REMOVEUNUSED
  group Source
    ./: delay.c uart0.c lcd1602_drv.c test-main.c
  group include
    ./include/: c51c5core.h interrupt.h io_x.h macrobin.h power.h timer01.h uart0.h stdint.h reg_x.h annex.h config.h
  group annex
    ./include/annex/: delay.h lcd1602_drv.h shift_drv.h soft_1wire.h soft_i2c.h
